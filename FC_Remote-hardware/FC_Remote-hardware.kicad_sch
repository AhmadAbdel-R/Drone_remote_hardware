File: FC_Remote-hardware/FC_Remote-hardware.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: added changes
Other:
- removed sheet SAMD21
